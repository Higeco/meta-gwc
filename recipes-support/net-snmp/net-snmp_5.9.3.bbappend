
EXTRA_OECONF += " \
    --with-security-modules=tsm \
    --with-transports='DTLSUDP TLSTCP' \
"
